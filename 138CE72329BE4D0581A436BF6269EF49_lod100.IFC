Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: C:\inetpub\wwwroot\LDAWP_Outbound\138CE72329BE4D0581A436BF6269EF49_lod100.IFC
Time: 2022-09-28T12:31:08
Made in: DigiPara Liftdesigner

# IfcBuilding, Document
LongName: Document
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.CreatedBy: INFO@ARITCO.COM; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 1473 mm; COBie.Type.NominalWidth: 1600 mm
DigiPara - DigiPara.IfcExportAs: IfcBuilding; DigiPara.IfcExportType: ELEVATOR; DigiPara.LDXType: LDXDocument; DigiPara.RevitTargetName: LDXDocument
Pset_TransportElementElevator - ClearDepth: 1100 mm; ClearHeight: 0 mm; ClearWidth: 1480 mm
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcBuildingSystem: Shaft Frame, ARITCO - PublicLift Access: PublicLift Access - MR Rear
PredefinedType: TRANSPORT; LongName: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.CreatedBy: INFO@ARITCO.COM; COBie.Type.Description: Shaft Frame; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 1473 mm; COBie.Type.NominalWidth: 1600 mm; COBie.Type.Size: 1473X1600
DigiPara - DigiPara.IfcExportAs: IfcBuildingSystem; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Document.; DigiPara.LDXType: LDXShaft; DigiPara.RevitTargetName: LDXShaft
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Frame; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Frame; OmniClass Number: 23.23.11.11; Type Comments: Shaft Frame
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Frame
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcSpatialZone: Shaft, Shaft0
In: Document
Description: Shaft; LongName: Hole0.; PredefinedType: OCCUPANCY; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
