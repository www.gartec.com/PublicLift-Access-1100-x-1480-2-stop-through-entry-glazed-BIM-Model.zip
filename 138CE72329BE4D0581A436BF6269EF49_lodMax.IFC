Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: C:\inetpub\wwwroot\LDAWP_Outbound\138CE72329BE4D0581A436BF6269EF49_lodMax.IFC
Time: 2022-09-28T12:31:14
Made in: DigiPara Liftdesigner

# IfcBuilding, Document
LongName: Document
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.CreatedBy: INFO@ARITCO.COM; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 1473 mm; COBie.Type.NominalWidth: 1600 mm
DigiPara - DigiPara.IfcExportAs: IfcBuilding; DigiPara.IfcExportType: ELEVATOR; DigiPara.LDXType: LDXDocument; DigiPara.RevitTargetName: LDXDocument
Pset_TransportElementElevator - ClearDepth: 1100 mm; ClearHeight: 0 mm; ClearWidth: 1480 mm
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcBuildingStorey (3)
In: Document
Name | LongName | Elevation (mm) | GrossHeight (mm)
Z -50 | Z -50 | -50 | 6200
0 | 0 | 0 | 3600
1 | 1 | 3600 | 2300

# IfcBuildingSystem: Shaft Frame, ARITCO - PublicLift Access: PublicLift Access - MR Rear
PredefinedType: TRANSPORT; LongName: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.CreatedBy: INFO@ARITCO.COM; COBie.Type.Description: Shaft Frame; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 1473 mm; COBie.Type.NominalWidth: 1600 mm; COBie.Type.Size: 1473X1600
DigiPara - DigiPara.IfcExportAs: IfcBuildingSystem; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Document.; DigiPara.LDXType: LDXShaft; DigiPara.RevitTargetName: LDXShaft
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Frame; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Frame; OmniClass Number: 23.23.11.11; Type Comments: Shaft Frame
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Frame
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcDoor: S1LD - LARGEGLASS, Shaft0.Entries3.E0.ShaftDoor
In: 1
Description: ARITCO - PUBLIC LIFT ACCESS DOORS/S1LD - LARGEGLASS/900; OverallHeight: 2000 mm; OverallWidth: 900 mm; PredefinedType: DOOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: S1LD - Full height; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS DOORS; COBie.Type.NominalHeight: 2000 mm; COBie.Type.NominalLength: 78.5 mm; COBie.Type.NominalWidth: 900 mm; COBie.Type.Size: 2000 x 900 x 78.5
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcDoor; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcFills: Parent.Opening.Hole0.; DigiPara.IfcParent: FloorLevel.; DigiPara.LDXType: LDXLandingDoor; DigiPara.RevitTargetName: LDXLandingDoor
Revit Standard Parameter - Assembly Code: D1010; Description: S1LD - Full height; Manufacturer: ARITCO - PUBLIC LIFT ACCESS DOORS; Model: S1LD - LARGEGLASS; OmniClass Number: 23.23.11.11.21.11; Type Comments: ARITCO PublicLift - Access
Pset_ManufacturerTypeInformation - ModelLabel: S1LD - LARGEGLASS
IfcDoor - OperationType: S1LD - Full height
IfcDoorPanelProperties - PanelOperation: Left Opening
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcDoor: S1RD - LARGEGLASS, Shaft0.Entries4.E0.ShaftDoor
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS DOORS/S1RD - LARGEGLASS/900; OverallHeight: 2000 mm; OverallWidth: 900 mm; PredefinedType: DOOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: S1RD - Full height; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS DOORS; COBie.Type.NominalHeight: 2000 mm; COBie.Type.NominalLength: 78.5 mm; COBie.Type.NominalWidth: 900 mm; COBie.Type.Size: 2000 x 900 x 78.5
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcDoor; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcFills: Parent.Opening.Hole0.; DigiPara.IfcParent: FloorLevel.; DigiPara.LDXType: LDXLandingDoor; DigiPara.RevitTargetName: LDXLandingDoor
Revit Standard Parameter - Assembly Code: D1010; Description: S1RD - Full height; Manufacturer: ARITCO - PUBLIC LIFT ACCESS DOORS; Model: S1RD - LARGEGLASS; OmniClass Number: 23.23.11.11.21.11; Type Comments: ARITCO PublicLift - Access
Pset_ManufacturerTypeInformation - ModelLabel: S1RD - LARGEGLASS
IfcDoor - OperationType: S1RD - Full height
IfcDoorPanelProperties - PanelOperation: Right Opening
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcRailing: ARITCO PublicLift Access - 1480, Shaft0.Car.Design.Wall2.HandRails
In: Z -50
Description: ARITCO-A7000-CAR-PLATFORMS/ARITCO PublicLift/Access - 1480; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Access - 1480; COBie.Type.Manufacturer: ARITCO-A7000-CAR-PLATFORMS; COBie.Type.NominalHeight: 0 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcRailing; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXCarHandRails; DigiPara.RevitTargetName: LDXCarHandRails
Revit Standard Parameter - Assembly Code: D1010; Manufacturer: ARITCO-A7000-CAR-PLATFORMS; Model: ARITCO PublicLift Access - 1480; OmniClass Number: 23.23.11.11.19; Type Comments: Access - 1480
Pset_ManufacturerTypeInformation - ModelLabel: ARITCO PublicLift Access - 1480
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcSwitchingDevice: ARITCO PublicLift Access - Call button (2)
Description: ARITCO - PUBLIC LIFT ACCESS DOORS/ARITCO PublicLift/Access - Call button; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Description: Access - Call button; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS DOORS; COBie.Type.NominalHeight: 0 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcSwitchingDevice; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcFills: Me.Hole0.; DigiPara.IfcParent: FloorLevel.; DigiPara.LDXType: LDXHallButton; DigiPara.RevitTargetName: LDXHallButton
Revit Standard Parameter - Assembly Code: D1010; Description: ARITCO PublicLift; Manufacturer: ARITCO - PUBLIC LIFT ACCESS DOORS; Model: ARITCO PublicLift Access - Call button; OmniClass Number: 23.23.11.11.21.13; Type Comments: Access - Call button
Pset_ManufacturerTypeInformation - ModelLabel: ARITCO PublicLift Access - Call button
Name | In
Shaft0.Entries3.E0.Panel0 | 1
Shaft0.Entries4.E0.Panel0 | 0

# IfcSwitchingDevice: ARITCO PublicLift Access 6000, Shaft0.Car.Panel0
In: Z -50
Description: ARITCO-A7000-CAR-PLATFORMS/ARITCO PublicLift/Access 6000; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Description: Access 6000; COBie.Type.Manufacturer: ARITCO-A7000-CAR-PLATFORMS; COBie.Type.NominalHeight: 0 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcSwitchingDevice; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcFills: Me.Hole0.; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXHallButton; DigiPara.RevitTargetName: LDXHallButton
Revit Standard Parameter - Assembly Code: D1010; Description: ARITCO PublicLift; Manufacturer: ARITCO-A7000-CAR-PLATFORMS; Model: ARITCO PublicLift Access 6000; OmniClass Number: 23.23.11.11.21.13; Type Comments: Access 6000
Pset_ManufacturerTypeInformation - ModelLabel: ARITCO PublicLift Access 6000
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: ARITCO PublicLift Access (2)
In: Z -50
Description: ARITCO-A7000-CAR-PLATFORMS/ARITCO PublicLift/Access; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Me.Shaft.FloorLevel.
Revit Standard Parameter - Assembly Code: D1010; Description: ARITCO PublicLift; Manufacturer: ARITCO-A7000-CAR-PLATFORMS; Model: ARITCO PublicLift Access; OmniClass Number: 23.23.11.11.19; Type Comments: Access
Pset_ManufacturerTypeInformation - ModelLabel: ARITCO PublicLift Access
Name | COBie.Type.NominalHeight (mm) | COBie.Type.NominalLength (mm) | COBie.Type.NominalWidth (mm) | DigiPara.LDXType = DigiPara.RevitTargetName
Shaft0.Car.Frame | 0 | 0 | 0 | LDXCarFrame | UK.COBie.Type - COBie.Type.Description: Access; COBie.Type.Manufacturer: ARITCO-A7000-CAR-PLATFORMS; ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C
Shaft0.Car.Platform | 30 | 1100 | 1480 | LDXCarPlatform | UK.COBie.Type - COBie.Type.Size: 1100X1480; Pset_TransportElementElevator - ClearDepth: 1100 mm; ClearWidth: 1480 mm

# IfcTransportElement: ARITCO PublicLift Access - Wall 2, Shaft0.Car.Design.Wall2
In: Z -50
Description: ARITCO-A7000-CAR-PLATFORMS/ARITCO PublicLift/Access - Wall 2; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Access - Wall 2; COBie.Type.Manufacturer: ARITCO-A7000-CAR-PLATFORMS; COBie.Type.NominalHeight: 1100 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Me.Shaft.FloorLevel.; DigiPara.LDXType: LDXCarWall; DigiPara.RevitTargetName: LDXCarWall
Revit Standard Parameter - Description: ARITCO PublicLift; Manufacturer: ARITCO-A7000-CAR-PLATFORMS; Model: ARITCO PublicLift Access - Wall 2; Type Comments: Access - Wall 2
Pset_ManufacturerTypeInformation - ModelLabel: ARITCO PublicLift Access - Wall 2
Pset_TransportElementElevator - ClearHeight: 1100 mm
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Architrave Left, Shaft0.Steel.ArchitraveLeft
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Architrave/Left; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Architrave Left; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Left; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 213 mm; COBie.Type.Size: 5950 x 213 x 0
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Architrave; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Architrave Left; OmniClass Number: 23.23.11.11; Type Comments: Left
Pset_ManufacturerTypeInformation - ModelLabel: Architrave Left
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Architrave Right, Shaft0.Steel.ArchitraveRight
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Architrave/Right; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Architrave Right; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Right; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 213 mm; COBie.Type.Size: 5950 x 213 x 0
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Architrave; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Architrave Right; OmniClass Number: 23.23.11.11; Type Comments: Right
Pset_ManufacturerTypeInformation - ModelLabel: Architrave Right
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Guide Rail (2)
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS MECHANICAL EQUIPMENT/ARITCO PublicLift/Access - Outer/Inner guide; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Description: Access - Outer/Inner guide; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS MECHANICAL EQUIPMENT; COBie.Type.NominalHeight: 0 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXGuide; DigiPara.RevitTargetName: LDXGuide
Revit Standard Parameter - Assembly Code: D1010; Description: ARITCO PublicLift; Manufacturer: ARITCO - PUBLIC LIFT ACCESS MECHANICAL EQUIPMENT; Model: ARITCO PublicLift Access - Outer/Inner guide; Type Comments: Access - Outer/Inner guide
Pset_ManufacturerTypeInformation - ModelLabel: ARITCO PublicLift Access - Outer/Inner guide
Name
Shaft0.Car.Frame.GuideList0.Guide0
Shaft0.Car.Frame.GuideList1.Guide0

# IfcTransportElement: Panels Front Lower, Shaft0.Steel.ShaftMastPanelsLowerFront
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Panels Front/Lower; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Panels Front Lower; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Lower; COBie.Type.NominalHeight: 4750 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 1600 mm; COBie.Type.Size: 4750 x 1600 x 752
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Panels Front; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Panels Front Lower; OmniClass Number: 23.23.11.11; Type Comments: Lower
Pset_ManufacturerTypeInformation - ModelLabel: Panels Front Lower
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Panels Front Upper, Shaft0.Steel.ShaftMastPanelsUpperFront
In: 1
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Panels Front/Upper; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Panels Front Upper; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Upper; COBie.Type.NominalHeight: 1200 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 1600 mm; COBie.Type.Size: 1200 x 1600 x 0
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Panels Front; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Panels Front Upper; OmniClass Number: 23.23.11.11; Type Comments: Upper
Pset_ManufacturerTypeInformation - ModelLabel: Panels Front Upper
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Panels Rear Rear, Shaft0.Steel.ShaftMastPanelsRear
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Panels Rear/Rear; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Panels Rear Rear; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Rear; COBie.Type.NominalHeight: 5950 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 1600 mm; COBie.Type.Size: 5950 x 1600 x 0
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Panels Rear; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Panels Rear Rear; OmniClass Number: 23.23.11.11; Type Comments: Rear
Pset_ManufacturerTypeInformation - ModelLabel: Panels Rear Rear
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Shaft Fixingpoints Building connection points, Shaft0.Steel.FixingPoints.FixingPoint_1
In: 1
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Shaft Fixingpoints/Building connection points; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Special Record: Use Color of parent object; COBie.Type.Description: Shaft Fixingpoints Building connection points; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Building connection points; COBie.Type.NominalHeight: 0 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 625 mm; COBie.Type.Size: 0 x 625 x 0
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Fixingpoints; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Fixingpoints Building connection points; OmniClass Number: 23.23.11.11; Type Comments: Building connection points
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Fixingpoints Building connection points

# IfcTransportElement: Shaft Frame Ceiling, Shaft0.Steel.ShaftInnerCeiling
In: 1
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Shaft Frame/Ceiling; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Shaft Frame Ceiling; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Ceiling; COBie.Type.NominalHeight: 1203 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 28 mm; COBie.Type.Size: 1203 x 28 x 1500
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Frame; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Frame Ceiling; OmniClass Number: 23.23.11.11; Type Comments: Ceiling
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Frame Ceiling
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Shaft Frame Corners and Bottom, Shaft0.Steel.ShaftSkeleton
In: 0
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Shaft Frame/Corners and Bottom; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Shaft Frame Corners and Bottom; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Corners and Bottom; COBie.Type.NominalHeight: 1557 mm; COBie.Type.NominalLength: 0 mm; COBie.Type.NominalWidth: 5950 mm; COBie.Type.Size: 1557 x 5950 x 1260
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Frame; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Frame Corners and Bottom; OmniClass Number: 23.23.11.11; Type Comments: Corners and Bottom
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Frame Corners and Bottom
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?m=7000&f=delta_dark_grey_vinyl&a=1100x1480&ch0=3400&ch1=2300&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&dt=large&dp1=C

# IfcTransportElement: Shaft Panel Blind (8)
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Shaft Panel/Blind; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Shaft Panel Blind; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Blind; COBie.Type.NominalLength: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Panel; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Panel Blind; OmniClass Number: 23.23.11.11; Type Comments: Blind
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Panel Blind
Name | In | COBie.Type.NominalHeight (mm) | COBie.Type.NominalWidth (mm) | COBie.Type.Size
Shaft0.Steel.Wall_A.Panel_1 | 0 | 1395 | 1257 | 1395 x 1257 x 25
Shaft0.Steel.Wall_A.Panel_5 | 1 | 60 | 1257 | 60 x 1257 x 25
Shaft0.Steel.Wall_B.Panel_1 | 0 | 65 | 1497 | 65 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_5 | 0 | 1392 | 1497 | 1392 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_9 | 1 | 60 | 1497 | 60 x 1497 x 25
Shaft0.Steel.Wall_C.Panel_1 | 0 | 65 | 1257 | 65 x 1257 x 25
Shaft0.Steel.Wall_C.Panel_5 | 0 | 1327 | 1257 | 1327 x 1257 x 25
Shaft0.Steel.Wall_C.Panel_6 | 1 | 63 | 1257 | 63 x 1257 x 25

# IfcTransportElement: Shaft Panel Glass T8 (12)
Description: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS/Shaft Panel/Glass T8; PredefinedType: ELEVATOR; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.Description: Shaft Panel Glass T8; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.Material: Glass T8; COBie.Type.NominalHeight: 736 mm; COBie.Type.NominalLength: 0 mm
DigiPara - DigiPara.IfcAssignsTo: Me.Shaft.; DigiPara.IfcExportAs: IfcTransportElement; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: NearestFloorLevel.; DigiPara.LDXType: LDXUserComp; DigiPara.RevitTargetName: LDXUserComp
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Panel; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Panel Glass T8; OmniClass Number: 23.23.11.11; Type Comments: Glass T8
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Panel Glass T8
Name | In | COBie.Type.NominalWidth (mm) | COBie.Type.Size
Shaft0.Steel.Wall_A.Panel_2 | 1 | 1257 | 736 x 1257 x 25
Shaft0.Steel.Wall_A.Panel_3 | 1 | 1257 | 736 x 1257 x 25
Shaft0.Steel.Wall_A.Panel_4 | 1 | 1257 | 736 x 1257 x 25
Shaft0.Steel.Wall_B.Panel_2 | 0 | 1497 | 736 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_3 | 0 | 1497 | 736 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_4 | 0 | 1497 | 736 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_6 | 1 | 1497 | 736 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_7 | 1 | 1497 | 736 x 1497 x 25
Shaft0.Steel.Wall_B.Panel_8 | 1 | 1497 | 736 x 1497 x 25
Shaft0.Steel.Wall_C.Panel_2 | 0 | 1257 | 736 x 1257 x 25
Shaft0.Steel.Wall_C.Panel_3 | 0 | 1257 | 736 x 1257 x 25
Shaft0.Steel.Wall_C.Panel_4 | 0 | 1257 | 736 x 1257 x 25
